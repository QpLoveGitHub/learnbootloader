# Keil uVision project test_iap_eeprom_bootloader.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: test_iap_eeprom_bootloader +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 bootloader.c delay.c test.c uart_stc89c52rc.c
