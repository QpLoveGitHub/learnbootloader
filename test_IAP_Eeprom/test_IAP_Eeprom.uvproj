# Keil uVision project test_IAP_Eeprom.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: test_IAP_Eeprom +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c uart_stc89c52rc.c iap_eeprom.c test.c STARTUP.A51
